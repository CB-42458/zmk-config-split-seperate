## config/boards/shields/left_side/Kconfig.defconfig
```kconfig
if SHIELD_LEFT_SIDE

config ZMK_KEYBOARD_NAME
    default "Redox Mod Left"

endif
```
